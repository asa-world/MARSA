# IAR project my_stm32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\User\Modules
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: my_stm32.hex
  ILINK.IlinkOutputFile: my_stm32.out
  ILINK.IlinkIcfFile: ..\EWARM\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    ./: system_stm32f10x.c
  group library
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ./: function.c function.h Interrupt.c Interrupt.h main.c
  group User/modules
    Modules/: 12864.c 12864.h Config.c Config.h Dht11.c Dht11.h i2c_eeprom.c i2c_eeprom.h Include.c Include.h Init.c Init.h Motor.c Motor.h SysTick.c SysTick.h Timer.c Timer.h Ultrasonic.c Ultrasonic.h usart1.c usart1.h usart3.c usart3.h
